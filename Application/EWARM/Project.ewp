# IAR project Project.ewp, settings and files
configuration STM32F769I-Discovery_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F769xx; USE_HAL_DRIVER; USE_STM32F769I_DISCO; ARM_MATH_CM7
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Inc; ..\Gui\Target; ..\Gui\STemWin_Addons; ..\cpu; ..\..\Utilities\JPEG; ..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\Drivers\BSP\Components; ..\..\Drivers\BSP\IKS01A3; ..\..\Drivers\BSP\Components\stts751; ..\..\Drivers\BSP\Components\otm8009a; ..\..\Drivers\BSP\Components\Common; ..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\Middlewares\ST\STemWin\inc; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Drivers\BSP\Components\hts221; ..\..\Drivers\BSP\Components\lps22hh; ..\WiFi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32F769I-DISCO_Demo.out
  ILINK.IlinkIcfFile: stm32f769xx.icf
  ILINK.IlinkExtraOptions: --diag_suppress Lt009
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Application/User/App
    ../Core/Src/: bsp.c main.c rtc.c systime.c ui.c wifi.c
    ../cpu/: cpu_utils.c
  group Application/User/Core
    ../Core/Src/: stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/GUI
    ../Resources/: background.c clock_icon.c Digita_Clock.c Digital_Font.c DigitGraphics20.c DigitGraphics40.c DigitGraphics60.c icon_home.c icon_indoor.c icon_internet.c icon_menu.c icon_outdoor.c icon_wifi.c location_icon.c profile_icon.c refresh_icon.c weather_day_clear.c weather_day_clouds.c weather_day_dizzle.c weather_day_thunderstorms.c weather_humidity.c weather_night_clear.c weather_night_clouds.c weather_pressure.c weather_temp.c weather_wind.c
  group Application/User/WiFi
    ../WiFi/: esp8266_wifi.c esp8266_wifi.h
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS03
    ../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors.h iks01a3_env_sensors_ex.c iks01a3_env_sensors_ex.h
  group Drivers/BSP/STM32769I-Discovery
    ../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Lib/IAR/: iar_cortexM7ls_math.a
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Drivers
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/STemWin/Library
    ../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc32_ot.a
  group Middlewares/STemWin/OS
    ../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STemWin_Addons_CM7_wc32.a
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf_CmdMode_TE.c
